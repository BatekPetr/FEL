# Keil uVision project dma.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: dma +hex
  c flags: Optim=1 wLevel=2
  c include: .;.\Libraries\CMSIS\Include;.\Libraries\CMSIS\Device\ST\STM32F10x\Include;.\Libraries\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./Libraries/CMSIS/Device/ST/STM32F10x/Source/: startup_stm32f10x_md.s system_stm32f10x.c
  group App
    ./: main.c stm32f1xx_it.c
